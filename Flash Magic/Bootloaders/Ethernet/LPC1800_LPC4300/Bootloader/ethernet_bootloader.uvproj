# Keil uVision project ethernet_bootloader.uvproj, settings and files
target iflash_keil_mcb_1857 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ethernet_bootloader +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\lpcopen_2_12\chip_18xx_43xx;.\lpcopen_2_12\chip_18xx_43xx\config_18xx;.\lpcopen_2_12\chip_common
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application
    ./: sbl_main.c sbl_config.h comms.c isp_iap.c timer.c
  group lpcopen_2_12
    ./lpcopen_2_12/chip_18xx_43xx/: enet_18xx_43xx.c clock_18xx_43xx.c rgu_18xx_43xx.c chip_18xx_43xx.c sysinit_18xx_43xx.c gpio_18xx_43xx.c emc_18xx_43xx.c timer_18xx_43xx.c stopwatch_18xx_43xx.c
  group Board
    ./: lpc_phy_dp83848.c board.c board_sysinit.c lpc_phy_smsc87x0.c
  group Startup
    ./: keil_startup_lpc18xx43xx.s sysinit.c
target iflash_keil_1857_xplorer (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  cpu: as above
  output: ethernet_bootloader +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: as above
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
