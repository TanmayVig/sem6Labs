# Keil uVision project ethernet_bootloader.uvproj, settings and files
target MCB1700 Board (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ethernet_bootloader +hex
  c flags: Optim=4
  c include: .;.\Core_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10003000 size 0x1000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: sbl_config.h
    ./startup/: startup_LPC17xx.s
    ./Core_CM3/: core_cm3.c
  group Board Init
    ./board_init/: board_init.c
  group Main
    ./: sbl_main.c comms.c
  group ISP
    ./isp/: isp_iap.c
  group EMAC
    ./ethernet/: emac.c mdio.c
  group Debug
    ./Debug/: uart.c
  group Timer
    ./timer/: timer.c
