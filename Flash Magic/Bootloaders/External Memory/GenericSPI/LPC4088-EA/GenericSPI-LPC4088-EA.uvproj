# Keil uVision project GenericSPI-LPC4088-EA.uvproj, settings and files
target RAM_M3 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: GenericSPI-LPC4088-EA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RAM_MODE__ USE_SPIFI_LIB CORE_M4
  c include: .\Core\CMSIS\Include;.\Core\Device\NXP\LPC407x_8x_177x_8x\Include;.\Drivers\include;..\..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x4700
  memory RVCT9: RAM 0x10004c00 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ./Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ./Drivers/lib/: spifi_drv_M4.lib
    ./Drivers/source/: lpc_systick.c lpc_clkpwr.c lpc_pinsel.c lpc_uart.c lpc_nvic.c
    ./: uart.c
  group Main
    ./: main.c
    ../../Core/: bootloader.c
  group Flash
    ./: FlashPrg.c
