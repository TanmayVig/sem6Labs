# Keil uVision project S25FL129P-LPC1850-Hitex.uvproj, settings and files
target Internal SRAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: S25FL129P-LPC1850 +hex
  c flags: Optim=1
  c define: CORE_M3 USE_SPIFI_LIB
  c include: .;.\lib;..\..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT6: RAM 0x28000000 size 0x800000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./lib/: startup_LPC18xx.s
  group CMSIS-CM3
    ./lib/: system_LPC18xx.c
  group Drivers
    ./lib/: lpc18xx_uart.c lpc18xx_scu.c lpc18xx_cgu.c
    ./: uart.c spifi_drv_M3.lib
  group Main
    ./: main.c
    ../../Core/: bootloader.c
  group Config
    ./: Internal SRAM.ini
  group Flash
    ./: FlashPrg.c
