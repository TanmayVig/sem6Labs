# Keil uVision project LPCxpresso54608.uvprojx, settings and files
target LPCxpresso54608 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: LPCxpresso54608 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: Include;drivers;.
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: keil_lib_power.lib 
--remove
  group startup
    ./: system_LPC54608.c system_LPC54608.h startup_LPC54608.s
  group source
    ./: main.c FlashPrg.c debug.c debug.h
    ../Core/: bootloader.c bootloader.h descriptor.h host.h swd.c
  group board
    ./: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
  group drivers
    ./drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_emc.c fsl_emc.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spifi.c fsl_spifi.h
    ./: fsl_flexcomm.c fsl_usart.c
target LPCxpresso54608 RAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: LPCxpresso54608 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: as above
  c include: Include;drivers;.;..\core
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20006500 size 0x2000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\LPC54608J512_ram.scf
  link misc: keil_lib_power.lib 
--remove
